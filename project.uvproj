# Keil uVision project project.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052 (all Variants) Generic
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: project +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\ws51f6240-main
  group Source Group 1
    ./: STARTUP.A51 main.c ws51f6240.h
